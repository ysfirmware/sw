# Keil uVision project AutoSolderController.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AutoSolderController +hex
  c flags: Optim=4
  c include: .\Source\header
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
  group source
    ./Source/: main.c SystemControl.c
  group util
    ./Source/util/: I2C_Eeprom.c uartproc.c util.c Modbus_Comm.c crc.c
  group Driver
    ./Source/Driver/: adcdef.c dmadef.c gpiodef.c i2cdef.c nvimdef.c spidef.c timerdef.c uartdef.c
    ./Source/: SystemSet.c
  group Header
    ./Source/header/: adcdef.h custmodel.h dmadef.h gpiodef.h I2c_eeprom.h i2cdef.h nvimdef.h process.h schedule.h spidef.h Systemcontrol.h timerdef.h uartdef.h uartproc.h util.h serial_flash.h Modbus_Comm.h heatproc.h crc.h max31855.h
  group process
    ./Source/process/: process.c schedule.c serial_flash.c Heatproc.c MAX31855.c
